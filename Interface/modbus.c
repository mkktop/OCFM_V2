/**
 * @file modbus.c
 * @brief Modbus核心功能实现
 * @details 提供CRC16校验、Modbus帧构建和解析等核心功能
 */

#include "modbus.h"

/**
 * @brief CRC高位查找表
 * @note 用于Modbus CRC16快速计算 (查表法)
 *       多项式: 0xA001 (标准Modbus RTU)
 */
static const uint8_t aucCRCHi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40
};

/**
 * @brief CRC低位查找表
 * @note 用于Modbus CRC16快速计算 (查表法)
 *       多项式: 0xA001 (标准Modbus RTU)
 */
static const uint8_t aucCRCLo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
    0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
    0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
    0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
    0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
    0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
    0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38,
    0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
    0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
    0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0x65, 0xA5, 0xA4, 0x64,
    0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB,
    0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
    0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
    0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
    0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
    0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
    0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x4D, 0x8D, 0x8C, 0x4C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
    0x41, 0x81, 0x80, 0x40
};

/**
 * @brief 计算Modbus CRC16校验码
 * @param buffer 数据缓冲区
 * @param length 数据长度
 * @return CRC16校验码 (16位)
 * @note 使用查表法，效率高
 *       Modbus RTU标准: 多项式0xA001, 初始值0xFFFF
 */
uint16_t modbus_crc16(uint8_t *buffer, uint16_t length)
{
    /* 初始化CRC值为0xFFFF */
    uint8_t  u8CRCHi = 0xFF;
    uint8_t  u8CRCLo = 0xFF;
    uint16_t u16Index;

    /* 遍历每个字节进行CRC计算 */
    while (length--)
    {
        /* 计算查表索引 */
        u16Index = u8CRCLo ^ *buffer++;
        /* 查表更新CRC值 */
        u8CRCLo = u8CRCHi ^ aucCRCHi[u16Index];
        u8CRCHi = aucCRCLo[u16Index];
    }

    /* 返回CRC值 (高字节在前) */
    return (uint16_t)((uint16_t)u8CRCHi << 8 | u8CRCLo);
}

/**
 * @brief 验证Modbus CRC16校验码
 * @param buffer 数据缓冲区 (包含CRC)
 * @param length 数据总长度 (包含2字节CRC)
 * @return 1:校验成功 0:校验失败
 * @note 从接收数据中提取CRC并与计算值比较
 */
uint8_t modbus_check_crc(uint8_t *buffer, uint16_t length)
{
    /* 数据长度至少包含: 地址(1) + 功能码(1) + CRC(2) = 4字节 */
    if (length < 4)
    {
        return 0;
    }

    /* 从数据帧末尾提取接收到的CRC (低字节在前) */
    uint16_t crc_received = buffer[length - 2] | (buffer[length - 1] << 8);
    /* 计算数据部分的CRC (不包含帧末尾的2字节CRC) */
    uint16_t crc_calculated = modbus_crc16(buffer, length - 2);

    /* 比较两者是否相等 */
    return (crc_received == crc_calculated) ? 1 : 0;
}

/**
 * @brief 构建Modbus读寄存器请求帧
 * @param buffer 输出缓冲区 (至少8字节)
 * @param slave_id 从机ID (1-247)
 * @param function_code 功能码 (0x03/0x04)
 * @param start_addr 起始地址
 * @param quantity 寄存器数量
 * @note 构建标准Modbus RTU请求帧，格式:
 *       [ID][功能码][起始地址高][起始地址低][数量高][数量低][CRC低][CRC高]
 */
void modbus_build_request(uint8_t *buffer, uint8_t slave_id, uint8_t function_code, 
                         uint16_t start_addr, uint16_t quantity)
{
    /* 填充从机地址 */
    buffer[0] = slave_id;
    /* 填充功能码 */
    buffer[1] = function_code;
    /* 填充起始地址 (高字节在前) */
    buffer[2] = (uint8_t)(start_addr >> 8);
    buffer[3] = (uint8_t)(start_addr & 0xFF);
    /* 填充寄存器数量 (高字节在前) */
    buffer[4] = (uint8_t)(quantity >> 8);
    buffer[5] = (uint8_t)(quantity & 0xFF);

    /* 计算CRC16并添加到帧末尾 */
    uint16_t crc = modbus_crc16(buffer, 6);
    buffer[6] = (uint8_t)(crc & 0xFF);   /* CRC低字节 */
    buffer[7] = (uint8_t)(crc >> 8);     /* CRC高字节 */
}

/**
 * @brief 构建Modbus异常响应帧
 * @param buffer 输出缓冲区 (至少5字节)
 * @param function_code 原始功能码
 * @param exception_code 异常代码
 * @return 响应帧长度 (5字节)
 * @note 异常响应格式: [ID][功能码|0x80][异常码][CRC低][CRC高]
 */
uint8_t modbus_build_exception_response(uint8_t *buffer, uint8_t function_code, uint8_t exception_code)
{
    /* 从机地址设为1 (可根据需要修改) */
    buffer[0] = 0x01;
    /* 功能码最高位置1表示异常 */
    buffer[1] = function_code | 0x80;
    /* 填充异常代码 */
    buffer[2] = exception_code;

    /* 计算CRC */
    uint16_t crc = modbus_crc16(buffer, 3);
    buffer[3] = (uint8_t)(crc & 0xFF);
    buffer[4] = (uint8_t)(crc >> 8);

    /* 返回响应帧长度 */
    return 5;
}

/**
 * @brief 解析Modbus响应数据
 * @param request 请求数据
 * @param response 响应数据
 * @param response_len 响应数据长度
 * @return 1:成功 0:失败
 * @note 验证从机ID、功能码和CRC
 */
uint8_t modbus_parse_response(uint8_t *request, uint8_t *response, uint16_t response_len)
{
    /* 响应帧最小长度: 地址(1) + 功能码(1) + CRC(2) = 4字节 */
    if (response_len < 4)
    {
        return 0;
    }

    /* 验证从机ID是否匹配 */
    if (request[0] != response[0])
    {
        return 0;
    }

    /* 检查是否为异常响应 (功能码最高位为1) */
    if (response[1] & 0x80)
    {
        return 0;
    }

    /* 验证功能码是否匹配 */
    if (request[1] != response[1])
    {
        return 0;
    }

    /* CRC校验 */
    if (!modbus_check_crc(response, response_len))
    {
        return 0;
    }

    return 1;
}